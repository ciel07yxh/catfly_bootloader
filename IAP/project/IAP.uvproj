# Keil uVision project IAP.uvproj, settings and files
target iap (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IAP +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ..\startup;..\cmsis;..\fwlib\inc;..\driver;..\main;..\app\command;..\app
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group cmsis
    ../cmsis/: core_cm3.c system_stm32f10x.c
  group fwlib
    ../fwlib/src/: misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group driver
    ../driver/: debugSerial.c delay.c sys.c flash.c
  group main
    ../main/: main.c mainInclude.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group app
    ../app/: iap.c
  group command
    ../app/command/: CommandCore.c commandFunc.c commandList.c commandUtil.c commandConfig.h commandInclude.h
