# Keil uVision project emoteboot.uvprojx, settings and files
target bootloader (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: emoteboot
  AfterMake: fromelf --bin --output=./Objects/emoteboot.bin ./Objects/emoteboot.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ./cmsis;./emlib;./src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group cmsis
    ./cmsis/: core_cm3.c system_stm32f10x.c core_cm3.h core_cmFunc.h core_cmInstr.h stm32f10x.h system_stm32f10x.h
  group emlib
    ./emlib/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h eeprom.h
  group src
    ./src/: stm32f10x_conf.h main.c startup_stm32f10x_xl.s stm32f10x_it.c stm32f10x_it.h usart.c
software components: CMSIS:CORE 4.3.0
